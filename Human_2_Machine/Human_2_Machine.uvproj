# Keil uVision project Human_2_Machine.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Human_2_Machine +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Hardware\h
  group Source Group 1
    ./User/: main.c
  group Hardware
    ./Hardware/c/: KeyScan.c OLED_GUI.c
